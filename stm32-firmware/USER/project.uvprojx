# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\FreeRTOS\inc;..\FreeRTOS\port;..\HARDWARE\control;..\HARDWARE\esp8266;..\HARDWARE\sensor;C:\Keil_v5\ARM\ARM_Compiler_5.06u7\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c
  group STM32F10_xFWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group HARDWARE
    ../HARDWARE/control/: control.c
    ../HARDWARE/esp8266/: esp8266.c
    ../HARDWARE/sensor/: sensor.c
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
